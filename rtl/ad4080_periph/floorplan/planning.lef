VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
MANUFACTURINGGRID 0.001 ;
MACRO WIN_FIFO_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 290.5 BY 88 ;
END WIN_FIFO_0
MACRO WIN_FIFO_1
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 290.5 BY 88 ;
END WIN_FIFO_1
MACRO WIN_FIFO_2
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 290.5 BY 88 ;
END WIN_FIFO_2
MACRO WIN_FIFO_3
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 290.5 BY 88 ;
END WIN_FIFO_3
MACRO WIN_SR2_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 130 BY 45 ;
END WIN_SR2_0
MACRO WIN_OTP_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 230 BY 423 ;
END WIN_OTP_0
MACRO WIN_DIO_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 853 BY 42 ;
END WIN_DIO_0
MACRO WIN_CLK_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 215 BY 86 ;
END WIN_CLK_0
MACRO WIN_RDAC_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 480 BY 638 ;
END WIN_RDAC_0
MACRO WIN_Q_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 334 BY 195 ;
END WIN_Q_0
MACRO WIN_Q_1
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 222 BY 215 ;
END WIN_Q_1
MACRO WIN_RA_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 306 BY 165 ;
END WIN_RA_0
MACRO WIN_ADC2_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 306 BY 115 ;
END WIN_ADC2_0
MACRO WIN_REF_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 1209 BY 88 ;
END WIN_REF_0
MACRO WIN_REF_1
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 346 BY 226 ;
END WIN_REF_1
MACRO WIN_LDO1_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 85 BY 245 ;
END WIN_LDO1_0
MACRO WIN_LDO2_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 93 BY 68 ;
END WIN_LDO2_0
MACRO WIN_CAP_0
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 44 BY 211 ;
END WIN_CAP_0
END LIBRARY
